Commit message: Teleopnode updated

File: omnirobot_ws/src/omnirobot/urdf/main.urdf.xacro (robot description, xacro)
@@ -58,5 +58,5 @@
   	</gazebo>
 	<gazebo reference="rim_right_link">
-    		<material>Gazebo/Blue</material>
+    		<material>Gazebo/Green</material>
   	</gazebo>
 	<gazebo>
